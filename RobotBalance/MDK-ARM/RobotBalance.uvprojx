# Keil uVision project RobotBalance.uvprojx, settings and files
target RobotBalance (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: RobotBalance +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,__CC_ARM,__TARGET_FPU_VFP,__FPU_USED=1U,__FPU_PRESENT=1U
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Module/Remind;../Module/Motor;../Module/Motor/LK_Motor;../Module/Motor/YS_Motor;../Task;../BSP/CAN;../Module/algorithm;../Middlewares/ST/ARM/DSP/Inc;../Drivers/CMSIS/DSP/Source/MatrixFunctions;../BSP/dwt;../BSP/UART;../Module/Remote/DR16;../Module/IMU/N100;../Task/MotorTask;../Robot_APP;../Robot_APP/chassis;../Task/ImuTask;../Module/IMU;../Module/IMU/HWT906;../Module/Motor/DM_Motor;../Module/IMU/BMI088;../Robot_APP/gimbal;../BSP/PWM;../Module/algorithm/mahony;../Module/Motor/DJI_Motor;../Robot_APP/shoot;../Module/SuperCap;../Module/IMU/CH040;../Module/Referee;../Module/CRC;../Module/Motor/Servo_motor;../Module/Remote/PC_Ctrl;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Module/Vision;../Module/Vision/SolveTrajectory
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group arm_math
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
    ../Drivers/CMSIS/DSP/Lib/ARM/: arm_cortexM7lfdp_math.lib
  group BSP
    ../BSP/CAN/: can_bsp.c
    ../BSP/DWT/: bsp_dwt.c
    ../BSP/UART/: bsp_uart.c
    ../BSP/PWM/: bsp_PWM.c
  group Module
    ../Module/Remind/: remind.c
    ../Module/Motor/LK_Motor/: LK_Motor.c
    ../Module/Motor/YS_Motor/: YS_Motor.c
    ../Module/algorithm/: crc8.c crc16.c kalman_filter.c QuaternionEKF.c user_lib.c controller.c
    ../Module/Remote/DR16/: DR16.c
    ../Module/IMU/N100/: IMU_N100.c
    ../Module/IMU/: ins_task.c
    ../Module/IMU/HWT906/: IMU_HWT906.c wit_c_sdk.c
    ../Module/Motor/DM_Motor/: DM_Motor.c
    ../Module/IMU/BMI088/: BMI088driver.c BMI088Middleware.c
    ../Module/algorithm/mahony/: mahony_filter.c
    ../Module/Motor/DJI_Motor/: DJI_Motor.c
    ../Module/SuperCap/: SuperCap.c
    ../Module/IMU/CH040/: IMU_CH040.c
    ../Module/Referee/: referee_task.c referee_UI.c rm_referee.c
    ../Module/CRC/: CRC.c
    ../Module/Motor/Servo_motor/: servo_motor.c
    ../Module/Remote/PC_Ctrl/: PC_Ctrl.c
    ../Module/Vision/: Vision.c
    ../Module/Vision/SolveTrajectory/: SolveTrajectory.c
  group Task
    ../Task/MotorTask/: MotorTask.c
    ../Task/ImuTask/: IMUTask.c
  group RoboAPP
    ../Robot_APP/chassis/: balance.c fly_detection.h linkNleg.h lqr_calc.h speed_estimation.h
    ../Robot_APP/gimbal/: gimbal.c
    ../Robot_APP/shoot/: shoot.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 6.1.0
